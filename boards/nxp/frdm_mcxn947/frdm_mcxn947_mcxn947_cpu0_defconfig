## boards/nxp/frdm_mcxn947/frdm_mcxn947_mcxn947_cpu0_defconfig
```kconfig
# The MCX-N trng is not hooked up, fallback to a non-secure RNG
CONFIG_TEST_RANDOM_GENERATOR=y
```
